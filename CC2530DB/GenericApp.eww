<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GenericApp.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>ALL</name>
            <member>
                <project>GenericApp</project>
                <configuration>DIYRuZ_E-monitor_epd154</configuration>
            </member>
            <member>
                <project>GenericApp</project>
                <configuration>DIYRuZ_E-monitor_epd213</configuration>
            </member>
            <member>
                <project>GenericApp</project>
                <configuration>DIYRuZ_E-monitor_epd29</configuration>
            </member>
            <member>
                <project>GenericApp</project>
                <configuration>DIYRuZ_E-monitor_epd37</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
